Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c59d7655-2cb6-4639-babc-c266bf37b57b, VersionGUID: a6566260-9f98-4a1f-a6ef-30fc5768efad, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: Progetto1.ifc
Time: 2024-09-17T16:07:02+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.20.41 (ITA) - IFC 24.2.20.41

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Estremità 8 mm
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcDiscreteAccessory: ROTHOB_Rothoblaas_Plate_RadialKit_Top:RADIALKIT60_40x51mm, ROTHOB_Rothoblaas_Plate_RadialKit_Top:RADIALKIT60_40x51mm:382032
In: Livello 2
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S355_Fe_Zn12c
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fisso; Category: Pr_20_29_03_10 - Carbon steel anchor plates; CECode: ETA-24/0062; CETitle: n/a; CodePerformance: CE - Construction products; Color: Grey; Constituents: Fasteners (bolt, washer, screw, nut); Description: Removable connector for beams and panels; DurationUnit: Years; ExpectedLife: n/a; Features: n/a; Finish: S355 + Fe/Zn12c; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 0.7 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RADIALKIT60; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_RadialKit_Top; NominalDepth: 4 cm; NominalHeight: n/a; NominalWidth: 5.1 cm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 40x51 mm; Size_Imperial: 1 9/16x2 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Vincoli - ModelNumberCode: 60; Prospetto di default: 0 cm
Type - Quote - BoltHeight: 7.5 cm; ElongatedNutHeight: 7.5 cm; FastenerDistance: 2.55 cm; ForkHeight: 7.6 cm; HexagonalHeadDiameter: 2.4 cm; PlateDepth_D: 4 cm; PlateHoleDiameter: 1.3 cm; PlateSemicircle: 2 cm; PlateThickness_s: 0.5 cm; PlateWidth_B: 5.1 cm; WasherThickness: 0.3 cm
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_RadialKit_Top; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.it/prodotti/fissaggio/piastre-e-connettori/angolari-e-piastre-per-edifici/radial#radial; Revision: n/a; UniClass2015Code: Pr_20_29_03_10; UniClass2015Title: Carbon steel anchor plates; UniClass2015Version: Products v1.33; Version: 1
Type - Dati identità - Nome del tipo: RADIALKIT60_40x51mm; Numero OmniClass: 23.13.23.11.19.13
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S355_Fe_Zn12c
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_29_03_10 - Carbon steel anchor plates
Pset_QuantityTakeOff - Reference: RADIALKIT60_40x51mm
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_RadialKit_Top; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_RadialKit_Top: RADIALKIT60_40x51mm; ID tipo: 382014; Tipo: RADIALKIT60_40x51mm
Vincoli - Host: Livello : Livello 2; Livello: Livello 2; Offset da host: 0 cm; Sposta con gli elementi più vicini: no
Quote - Area: 0.000135297 m2; Volume: 0.0000833282 m3
Fasi - Fase di creazione: Nuova costruzione
Visibilità - HasText: no
