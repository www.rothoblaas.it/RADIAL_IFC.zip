Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c59d7655-2cb6-4639-babc-c266bf37b57b, VersionGUID: a6566260-9f98-4a1f-a6ef-30fc5768efad, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: ROTHOB_Rothoblaas_Bolt_RadialBolt_1245.ifc
Time: 2024-09-17T16:36:56+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.20.41 (ITA) - IFC 24.2.20.41

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Estremità 8 mm
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16:RADBOLT1245_19x45mm, ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16:RADBOLT1245_19x45mm:382032
In: Livello 2
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_08_76 - Shear bolts; CodePerformance: CE - Construction products; Color: Grey; Constituents: n/a; Description: n/a; DurationUnit: n/a; ExpectedLife: n/a; Features: n/a; Finish: Electrogalvanized; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: n/a; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RADBOLT1245; ModelReference: n/a; Name: Bolt; Nome famiglia: ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16; NominalDiameter: 1.9 cm; NominalHeight: n/a; NominalLength: 4.5 cm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 19x45 mm; Size_Imperial: 3/4x1 3/4 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Vincoli - ModelNumberCode: 1245; Prospetto di default: 0.131234 cm
Type - Quote - BoltDiameter_d: 1.2 cm; BoltLength_L: 4.5 cm; HexagonalHeadDiameter_SW: 1.9 cm; HexagonalHeadThickness: 1 cm
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 13 21; OmniClassTitle: Bolts and nuts; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.it/prodotti/fissaggio/piastre-e-connettori/angolari-e-piastre-per-edifici/radial#radial; Revision: n/a; UniClass2015Code: Pr_20_29_08_76; UniClass2015Title: Shear bolts; UniClass2015Version: Products v1.33; Version: 1
Type - Dati identità - Nome del tipo: RADBOLT1245_19x45mm; Numero OmniClass: 23.13.23.11.13.21
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Bolt; Category: Pr_20_29_08_76 - Shear bolts
Pset_BuildingElementProxyCommon - Reference: RADBOLT1245_19x45mm; sets with these values: 2
Altro - Famiglia: ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16; Famiglia e tipo: ROTHOB_Rothoblaas_Bolt_RadialBolt_12-16: RADBOLT1245_19x45mm; ID tipo: 385888; InstallationDate: n/a; Tipo: RADBOLT1245_19x45mm; WarrantyStartDate: n/a
Vincoli - Host: Livello : Livello 2; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: 0 cm
Quote - Volume: 0.00000821549 m3
Fasi - Fase di creazione: Nuova costruzione
