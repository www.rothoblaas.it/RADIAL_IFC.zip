Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 857116ea-e036-404b-b95a-e62b1932bcdd, VersionGUID: 779ecad8-9d33-47a9-91bb-c7657642beed, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: ROTHOB_Rothoblaas_Nut_Radial_93416.ifc
Time: 2024-09-19T10:48:45+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.20.41 (ITA) - IFC 24.2.20.41

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Estremità 8 mm
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_Nut_Radial_12-16:MUT93416_24x13mm, ROTHOB_Rothoblaas_Nut_Radial_12-16:MUT93416_24x13mm:381655
In: Livello 2
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_08_11 - Carbon steel hexagon-headed nuts and bolts; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: n/a; DurationUnit: n/a; ExpectedLife: n/a; Features: n/a; Finish: Electrogalvanized; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: n/a; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: MUT93416; ModelReference: n/a; Name: Nut; Nome famiglia: ROTHOB_Rothoblaas_Nut_Radial_12-16; NominalDiameter: 2.4 cm; NominalHeight: 1.3 cm; NominalLength: n/a; NominalWidth: n/a; ReplacementCost: n/a; Shape: Three-dimensional; Size: 24x13 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Vincoli - ModelNumberCode: 93416; Prospetto di default: 0.131234 cm
Type - Quote - HexagonalHeadDiameter_SW: 2.4 cm; HexagonalHeadHeight_h: 1.3 cm; InnerDiameter: 1.6 cm
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Nut_MUT934; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 13 21; OmniClassTitle: Bolts and nuts; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.it/prodotti/fissaggio/piastre-e-connettori/angolari-e-piastre-per-edifici/radial#radial; Revision: n/a; UniClass2015Code: Pr_20_29_08_11; UniClass2015Title: Carbon steel hexagon-headed nuts and bolts; UniClass2015Version: Products v1.33; Version: 1
Type - Dati identità - Nome del tipo: MUT93416_24x13mm; Numero OmniClass: 23.13.23.11.13.21
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Nut; Category: Pr_20_29_08_11 - Carbon steel hexagon-headed nuts and bolts
Pset_BuildingElementProxyCommon - Reference: MUT93416_24x13mm; sets with these values: 2
Altro - Famiglia: ROTHOB_Rothoblaas_Nut_Radial_12-16; Famiglia e tipo: ROTHOB_Rothoblaas_Nut_Radial_12-16: MUT93416_24x13mm; ID tipo: 381605; InstallationDate: n/a; Tipo: MUT93416_24x13mm; WarrantyStartDate: n/a
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: -300 cm
Quote - Volume: 0.00000387141 m3
Fasi - Fase di creazione: Nuova costruzione
