Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 87ba9560-e27f-4e5b-86e7-59b3375f4677, NumberOfSaves: 9], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_Radial_60D.ifc
Time: 2025-05-14T17:52:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_Radial : RADIAL60D_60x55x49mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S355-Fe/Zn12c
Type - Visibilità - HasWeb_RADIAL60S: no; HasWeb_RADIAL90/RADIAL60D: yes
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_Radial; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/radial; Revision: 001; UniClass2015Code: Pr_20_85_30_17; UniClass2015Title: Carbon steel spliced connectors; UniClass2015Version: Products v1.37; Version: 001
Type - Vincoli - ModelNumberCode: 601; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S355-Fe/Zn12c
Type - Quote - AngleA: 30 deg; AngleB: 48 deg; AngleC: 48 deg; BFlangeDistance: 8.5 mm; CylinderInnerRadius: 26.1 mm; CylinderThickness: 4 mm; Depth_B: 55 mm; Diameter_D: 60.2 mm; FlangeAngle: 45.1379 deg; FlangeDistance: 30 mm; FlangeHeight: 55 mm; FlangeHoleDiameterA: 10.2 mm; FlangeHoleDiameterB: 13 mm; FlangeInnerDiameter: 37 mm; FlangeThickness: 4 mm; Height_H: 49 mm; HoleDiameter: 7.5 mm; HolesDisplacement: 5 mm; SemicircleHeight: 30.15 mm
Type - Dati identità - Descrizione: Removable connector for beams and panels; Nome del tipo: RADIAL60D_60x55x49mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_30_17 - Carbon steel spliced connectors; CECode: ETA-24/0062; CETitle: Rotho Blaas RADIAL connectors; CodePerformance: CE - Construction products; Color: Grey; Constituents: Fasteners (bolt, washer, screw, nut); Descriptiom: Removable connector for beams and panels; DurationUnit: Years; ExpectedLife: n/a; Features: n/a; Finish: S355 + Fe/Zn12c; Grade: n/a; GTIN: 8054045430065; Material: S355 + Fe/Zn12c Carbon steel; MinWeight: 0.238 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RADIAL60D; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_Radial; NominalDepth: 55 mm; NominalDiameter: 60.2 mm; NominalHeight: 49 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Three-dimensional; Size: 60x55x49 mm; Size_Imperial: 2 3/8x2 3/16x1 15/16 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_85_30_17 - Carbon steel spliced connectors
Pset_QuantityTakeOff - Reference: RADIAL60D_60x55x49mm
Visibilità - HasText: no
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.0110236 m2; Volume: 0.0000301527 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_Radial; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_Radial: RADIAL60D_60x55x49mm; ID tipo: 264055; Tipo: RADIAL60D_60x55x49mm
