Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: a42e152c-6b4b-4dc5-9b91-702de66fa611, NumberOfSaves: 10], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_RadialKit_Bottom_60_RADBOLT16180.ifc
Time: 2025-05-14T18:09:50
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_RadialKit_Bottom : RADIALKIT60_40x51mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S355_Fe_Zn12c
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_RadialKit_Bottom; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.it/prodotti/fissaggio/piastre-e-connettori/angolari-e-piastre-per-edifici/radial#radial; Revision: n/a; UniClass2015Code: Pr_20_29_03_10; UniClass2015Title: Carbon steel anchor plates; UniClass2015Version: Products v1.33; Version: 1
Type - Vincoli - ModelNumberCode: 60; Prospetto di default: 0 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S355_Fe_Zn12c
Type - Quote - ElongatedNutHeight: 75 mm; FastenerDistance: 25.5 mm; ForkHeight: 76 mm; HexagonalHeadDiameter: 24 mm; PlateDepth_D: 40 mm; PlateHoleDiameter: 13 mm; PlateSemicircle: 20 mm; PlateThickness_s: 5 mm; PlateWidth_B: 51 mm; WasherThickness: 3 mm
Type - Dati identità - Nome del tipo: RADIALKIT60_40x51mm; Numero OmniClass: 23.13.23.11.19.13
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fisso; Category: Pr_20_29_03_10 - Carbon steel anchor plates; CECode: ETA-24/0062; CETitle: n/a; CodePerformance: CE - Construction products; Color: Grey; Constituents: Fasteners (bolt, washer, screw, nut); Description: Removable connector for beams and panels; DurationUnit: Years; ExpectedLife: n/a; Features: n/a; Finish: S355 + Fe/Zn12c; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 0.7 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RADIALKIT60; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_RadialKit_Bottom; NominalDepth: 40 mm; NominalHeight: n/a; NominalWidth: 51 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 40x51 mm; Size_Imperial: 2 3/8x2 3/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_29_03_10 - Carbon steel anchor plates
Pset_QuantityTakeOff - Reference: RADIALKIT60_40x51mm
Visibilità - HasText: no
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Offset da host: 0 mm; Sposta con l'oggetto più vicino: no
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.000135258 m2; BoltHeight: 180 mm; Volume: 0.0000827871 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_RadialKit_Bottom; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_RadialKit_Bottom: RADIALKIT60_40x51mm; ID tipo: 274815; Tipo: RADIALKIT60_40x51mm
